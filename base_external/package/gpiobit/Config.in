## base_external/package/gpiobit/Config.in
```kconfig
config BR2_PACKAGE_GPIOBIT
	bool "gpiobit"
	help
	  Includes gpiobit module in the kernel image.
```
